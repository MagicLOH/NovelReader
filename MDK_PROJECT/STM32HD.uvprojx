# Keil uVision project STM32HD.uvprojx, settings and files
target STM32HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32HD
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,DATA_IN_ExtSRAM
  c include: ..\SYSLIB;..\SYSTEM\BEEP;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\SYSTEM\LED;..\SYSTEM\KEY;..\SYSTEM\USART;..\SYSTEM\TIMER;..\SYSTEM\W25Q64;..\SYSTEM\SPI;..\SYSTEM\W25Q64;..\SYSTEM\IIC;..\SYSTEM\AT24C08;..\SYSTEM\INFRARED;..\SYSTEM\LCD;..\SYSTEM\TOUCH;..\SYSTEM\SRAM;..\SYSTEM\WDG;..\SYSTEM\SDCARD;..\FATFS;..\SYSTEM\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x68000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c
  group SYSLIB
    ../SYSLIB/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/BEEP/: beep.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/LED/: led.c
    ../SYSTEM/KEY/: key.c
    ../SYSTEM/USART/: usart.c
    ../SYSTEM/TIMER/: timer.c
    ../SYSTEM/SPI/: spi.c
    ../SYSTEM/W25Q64/: w25q64.c
    ../SYSTEM/IIC/: iic.c
    ../SYSTEM/AT24C08/: at24c08.c
    ../SYSTEM/INFRARED/: infrared.c
    ../SYSTEM/LCD/: nt35310.c bmp_320_480.c gbk_16_16_1.c gbk_16_16_2.c ascii.c
    ../SYSTEM/TOUCH/: xpt2046.c
    ../SYSTEM/SRAM/: sram.c
    ../SYSTEM/WDG/: wdg.c
    ../SYSTEM/SDCARD/: sdcard.c fileapp.c
    ../SYSTEM/RTC/: rtc.c
  group FATFS
    ../FATFS/: diskio.c ff.c ffsystem.c ffunicode.c ffconf.h
